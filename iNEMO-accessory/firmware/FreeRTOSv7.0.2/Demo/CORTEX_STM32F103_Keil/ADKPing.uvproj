# Keil uVision project ADKPing.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ADKPing
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102  STM32F10X_CL
  c include: .\iNEMO_task;..\Common\include;..\..\Source\include;.\STM32F10xFWLib\inc;.\USB_Host_Shield;.\AndroidAccessory;.\Sensors\STLM75\inc;.\Sensors\LPRYxxxAL\inc;.\Sensors\LPS001DL\inc;.\Sensors\LSM303DLH\inc;.\Sensors\iNEMO_Config\inc;.\Sensors\utils\inc;.\CommunicationManager
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ./Startup files/: STM32F10x.s
    ../Common/drivers/ST/STM32F10xFWLib/src/: cortexm3_macro_rvds.s
    ./STM32F10xFWLib/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_lib.c stm32f10x_i2c.c
    ./iNEMO_task/: iNEMO_util.c
  group Demo Files
    ./serial/: serial.c
    ./USB_Host_Shield/: Max3421e.c Usb.c
    ./AndroidAccessory/: AndroidAccessory.c
    ./iNEMO_task/: main.c
    ./CommunicationManager/: comManager.c
  group FreeRTOS files
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_2.c
  group Sensors
    ./Sensors/STLM75/src/: STLM75.c
    ./Sensors/LSM303DLH/src/: LSM303DLH.c
    ./Sensors/iNEMO_Config/src/: iNEMO_lib.c
    ./Sensors/utils/src/: utils.c
